Commit message: Change NB2 parameters for new motor base

File: neuronbot2_description/urdf/neuronbot2.urdf (robot description, URDF)
Before this commit: robot neuronbot2_description, 7 links, 6 joints
Joints:
- joint imu_joint: origin xyz=0.075 0 0.138 rpy=0 0 1.57 -> xyz=0.075 0 0.138 rpy=0 0 0
